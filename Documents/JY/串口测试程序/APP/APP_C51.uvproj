# Keil uVision project APP_C51.uvproj, settings and files
target App_C51 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: App +hex
  AfterMake: .\copy.bat
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src\Delay;.\src\Key;.\src\Msg;.\src\Uart;.\src\Ui;.\src\User;.\src\Ui\ui_common;.\src\Ui\Lcd_seg;.\src\Ui\Led_seg;.\src\Ui\resourc;.\src\SPI;.\src\SD
  group User
    ./src/User/: Main.c
  group Uart
    ./src/Uart/: UART.C
